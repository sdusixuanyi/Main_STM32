# IAR project CarryPilot.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PM; TARGET_IS_TM4C123_RB1
  ICCARM.CCIncludePath2: Libraries\driverlib; Libraries\inc; Libraries\utils; WP_Src; WP_Ctrl; User
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: Libraries\driverlib; Libraries\inc; Libraries\utils; WP_Ctrl; WP_Src; User
  OBJCOPY.OOCOutputFile: CarryPilot.hex
  ILINK.IlinkOutputFile: CarryPilot.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\TexasInstruments\TM4C123GH6.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group CP_Ctrl
    WP_Ctrl/: CalibrationRoutines.c CalibrationRoutines.h control_althold.c control_althold.h control_config.h control_land.c control_land.h control_poshold.c control_poshold.h Earth_Declination.c Earth_Declination.h NamelessCorun_OpticalFlow.h NamelessCorun_OpticalFlow.o NamelessCotrun_SDK.c NamelessCotrun_SDK.h OpticalFlow_Control.c OpticalFlow_Control.h Sensor.c Sensor.h WP_Ctrl.c WP_Ctrl.h
  group CP_Src
    WP_Src/: Bling.c Bling.h Calibration.c Calibration.h Filter.c Filter.h GPS.c GPS.h IST8310.c IST8310.h Key.c Key.h mpu6050.c mpu6050.h myiic.c myiic.h OLED.c OLED.h oledfont.h OpticalFlow_LC306.c OpticalFlow_LC306.h PID.c PID.h PPM.h PPM.o RC.c RC.h Ringbuf.c Ringbuf.h Schedule.c Schedule.h SINS.c SINS.h SPL06.c SPL06.h ssd1306.c SYSTEM.c SYSTEM.h Time.c Time.h Time_Cnt.c Time_Cnt.h US_100.c US_100.h Usart.c Usart.h WP_ADC.c WP_ADC.h WP_DataType.h wp_flash.c wp_flash.h WP_Math.c WP_Math.h WP_PWM.c WP_PWM.h
  group Library
    Libraries/driverlib/: adc.c adc.h aes.c aes.h can.c can.h comp.c comp.h cpu.c cpu.h crc.c crc.h debug.h des.c des.h eeprom.c eeprom.h emac.c emac.h epi.c epi.h flash.c flash.h fpu.c fpu.h gpio.c gpio.h i2c.c i2c.h interrupt.c interrupt.h lcd.c lcd.h mpu.c mpu.h pin_map.h pwm.c pwm.h qei.c qei.h rom.h rom_map.h rtos_bindings.h shamd5.c shamd5.h ssi.c ssi.h sw_crc.c sw_crc.h sysctl.c sysctl.h sysexc.c sysexc.h systick.c systick.h timer.c timer.h uart.c uart.h udma.c udma.h usb.c usb.h watchdog.c watchdog.h
  group User
    User/: Headfile.h main.c startup_ewarm.c
    Libraries/utils/: uartstdio.c
