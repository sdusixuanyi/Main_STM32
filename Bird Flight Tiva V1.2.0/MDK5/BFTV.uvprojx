# Keil uVision project BFTV.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BFTV
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_BLIZZARD_RB1
  c misc: --c99
  c include: ..\Libraries\utils;..\Libraries\inc;..\Libraries\driverlib;..\User;..\WP_Ctrl;..\WP_Src
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CP_Ctrl
    ../WP_Ctrl/: CalibrationRoutines.c CalibrationRoutines.h control_althold.c control_althold.h control_config.h control_land.c control_land.h control_poshold.c control_poshold.h Earth_Declination.c Earth_Declination.h NamelessCorun_OpticalFlow.h NamelessCotrun_SDK.c NamelessCotrun_SDK.h OpticalFlow_Control.c OpticalFlow_Control.h Sensor.c Sensor.h WP_Ctrl.c WP_Ctrl.h NamelessCorun_OpticalFlow.o
  group CP_Src
    ../WP_Src/: Bling.c Bling.h Calibration.c Calibration.h Filter.c Filter.h GPS.c GPS.h IST8310.c IST8310.h Key.c Key.h mpu6050.c mpu6050.h myiic.c myiic.h OLED.c OLED.h oledfont.h OpticalFlow_LC306.c OpticalFlow_LC306.h PID.c PID.h PPM.h RC.c RC.h Ringbuf.c Ringbuf.h Schedule.c Schedule.h SINS.c SINS.h SPL06.c SPL06.h ssd1306.c ssd1306.h SYSTEM.c SYSTEM.h Time.c Time.h Time_Cnt.c Time_Cnt.h US_100.c US_100.h Usart.c Usart.h WP_ADC.c WP_ADC.h WP_DataType.h wp_flash.c wp_flash.h WP_Math.c WP_Math.h WP_PWM.c WP_PWM.h PPM.o
  group Library
    ../Libraries/driverlib/: adc.c adc.h aes.c aes.h can.c can.h comp.c comp.h cpu.c cpu.h crc.c crc.h debug.h des.c des.h eeprom.c eeprom.h emac.c emac.h epi.c epi.h flash.c flash.h fpu.c fpu.h gpio.c gpio.h i2c.c i2c.h interrupt.c interrupt.h lcd.c lcd.h mpu.c mpu.h pin_map.h pwm.c pwm.h qei.c qei.h rom.h rom_map.h rtos_bindings.h shamd5.c shamd5.h ssi.c ssi.h sw_crc.c sw_crc.h sysctl.c sysctl.h sysexc.c sysexc.h systick.c systick.h timer.c timer.h uart.c uart.h udma.c udma.h usb.c usb.h watchdog.c watchdog.h
    ../Libraries/driverlib/rvmdk/: driverlib.lib
  group User
    ../User/: main.c Headfile.h
    ../Libraries/utils/: uartstdio.c
    ./: startup_rvmdk.S
