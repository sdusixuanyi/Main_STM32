# Keil uVision project TEST1.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TEST1 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\USER;..\STM32F10X_FWLib\inc;..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWEAR\inc;..\USMART;..\MATH\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group STM32F10X_FWLIB
    ../STM32F10X_FWLib/src/: stm32f10x_adc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c misc.c stm32f10x_spi.c stm32f10x_dma.c
  group HARDWARE
    ../HARDWEAR/scr/: led.c key.c pwm.c beep.c 24l01.c spi.c adc.c HCSR04.c dma.c timer.c i2c.c mpu6050.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: sys.c
  group README
    ../readme/: guanjiao.txt member.txt
  group MATH
    ../MATH/scr/: flight_control.c kalman.c myMath.c
